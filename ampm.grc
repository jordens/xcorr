<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Ampm</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"{:s}_f0{:.5g}_fs{:.5g}_d{:.5g}".format(name, f_source/1e6, f_sample/1e6, decim)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>info</value></param>
<param><key>value</key><value>{"name":name, "f_source":f_source, "f_sample":f_sample, "decim":decim}</value></param>
</block>
<block>
<key>NoiseConvert2</key>
<param><key>id</key><value>NoiseConvert2_0</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_0.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>decim</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_1.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>100000</value></param>
<param><key>rel_rate</key><value>int(decim**2)</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_2</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_2.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000</value></param>
<param><key>rel_rate</key><value>int(decim**3)</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>n_samples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>num_items</key><value>n_samples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0_0</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>host</value></param>
<param><key>port</key><value>6881</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1200</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0_0</value></param>
<param><key>ipaddr</key><value>host</value></param>
<param><key>port</key><value>6882</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>16</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_df</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_source</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1.</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_0</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1.</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_1_0_0</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1.</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_samples</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1&lt;&lt;24</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test6</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>output pm in radian as imag, output am (sig-ref)/(sig+ref) as real</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>in</value></param>
<param><key>num_streams</key><value>2</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>ampm</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>f_source</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>f_source</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>fpga=usrp_b100_fpga_2rx.bin</value></param>
<param><key>sd_spec0</key><value>A:A A:B</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>NoiseConvert2_0</source_block_id><sink_block_id>low_pass_filter_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0</source_block_id><sink_block_id>blocks_message_source_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0_0</source_block_id><sink_block_id>blocks_message_source_0_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_source_0_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>blocks_message_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>low_pass_filter_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_0</source_block_id><sink_block_id>blocks_message_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_0</source_block_id><sink_block_id>low_pass_filter_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_0_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_1_0_0</source_block_id><sink_block_id>blocks_udp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>NoiseConvert2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>NoiseConvert2_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>

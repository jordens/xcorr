<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ampm_cli</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"{:s}_f0{:.5g}_f1{:.5g}_fs{:.5g}_d{:.5g}".format(name, f_sig/1e6, f_ref/1e6, f_sample/1e6, decim)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>info</value></param>
<param><key>value</key><value>{"name":name, "f_sig":f_sig, "f_ref":f_ref, "f_sample":f_sample, "decim":decim}</value></param>
</block>
<block>
<key>Ampm</key>
<param><key>id</key><value>Ampm_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>decim_df</key><value>decim_df</value></param>
<param><key>decim_f</key><value>decim_f</value></param>
<param><key>f_ref</key><value>f_ref</value></param>
<param><key>f_sample</key><value>f_sample</value></param>
<param><key>f_sig</key><value>f_sig</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_2.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**1</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_1</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_1.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**2</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_3</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_0.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**3</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_3_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_w.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**3</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>n_samples/decim**2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>n_samples/decim**1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0]]</value></param>
<param><key>comment</key><value>apparently drives the flowgraph</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_df</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_ref</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sig</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_samples</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1&lt;&lt;24</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pass_tags</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>tcp://localhost:6882</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_1</value></param>
<param><key>address</key><value>tcp://localhost:6881</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_2</value></param>
<param><key>address</key><value>tcp://localhost:6880</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_2_0</value></param>
<param><key>address</key><value>tcp://localhost:6889</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_1</source_block_id><sink_block_id>blocks_file_meta_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_1</source_block_id><sink_block_id>blocks_head_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_2</source_block_id><sink_block_id>blocks_file_meta_sink_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_2_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

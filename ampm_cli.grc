<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ampm_cli</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"{:s}_f0{:.5g}_df{:.5g}_fs{:.5g}_d{:.5g}".format(name, f_sig/1e6, df_ref, f_sample/1e6, decim)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>info</value></param>
<param><key>value</key><value>{"name":name, "f_sig":f_sig, "df_ref":df_ref, "f_sample":f_sample, "decim":decim}</value></param>
</block>
<block>
<key>Ampm</key>
<param><key>id</key><value>Ampm_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>decim_df</key><value>decim_df</value></param>
<param><key>decim_f</key><value>decim_f</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>df_test</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_ctrlport_monitor</key>
<param><key>id</key><value>blocks_ctrlport_monitor_0</value></param>
<param><key>en</key><value>True</value></param>
</block>
<block>
<key>blocks_ctrlport_probe2_c</key>
<param><key>id</key><value>blocks_ctrlport_probe2_c_0</value></param>
<param><key>desc</key><value>input a</value></param>
<param><key>disp_mask</key><value>gr.DISPTIME</value></param>
<param><key>len</key><value>1024</value></param>
<param><key>name</key><value>a</value></param>
</block>
<block>
<key>blocks_ctrlport_probe2_c</key>
<param><key>id</key><value>blocks_ctrlport_probe2_c_0_0</value></param>
<param><key>desc</key><value>input b</value></param>
<param><key>disp_mask</key><value>gr.DISPTIME</value></param>
<param><key>len</key><value>1024</value></param>
<param><key>name</key><value>b</value></param>
</block>
<block>
<key>blocks_ctrlport_probe2_c</key>
<param><key>id</key><value>blocks_ctrlport_probe2_c_0_1</value></param>
<param><key>desc</key><value>diff0</value></param>
<param><key>disp_mask</key><value>gr.DISPTIME</value></param>
<param><key>len</key><value>1024</value></param>
<param><key>name</key><value>d0</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_2.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**1</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_3.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**0</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**3</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_1</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_1.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**2</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_3</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_0.bin".format(filename)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**3</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0_3_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>"{}_w.bin".format(filename)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max_seg_size</key><value>1&lt;&lt;20</value></param>
<param><key>rel_rate</key><value>decim**3</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>n_samples/decim**2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_0</value></param>
<param><key>num_items</key><value>n_samples/decim**3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>decim**3</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0_1</value></param>
<param><key>num_items</key><value>n_samples/decim**1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>num_items</key><value>n_samples/decim**3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>decim**3</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>decim**1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>decim**0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>decim**0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>decim**2</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>decim**3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_df</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_address</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>type=b100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_address</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>type=b200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_arguments</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"fpga=usrp_b100_fpga_2rx.bin"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device_arguments</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"master_clock_rate=30.72e6"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>df_ref</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>df_test</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_dsp</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>960e3*4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sig</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>6e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>g_ref</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>g_sig</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>g_test</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>49</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_samples</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1&lt;&lt;24</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pass_tags</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port_base</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>6880</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>f_sig</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>g_test</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>f_sig</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>g_test</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>device_address</value></param>
<param><key>dev_args</key><value>device_arguments</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>30.72e6</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(target_freq=f_sig , dsp_freq=f_dsp, rf_freq_policy=uhd.tune_request.POLICY_AUTO, dsp_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>g_sig</value></param>
<param><key>ant1</key><value></value></param>
<param><key>bw1</key><value>30.72e6</value></param>
<param><key>center_freq1</key><value>uhd.tune_request(target_freq=f_sig + df_ref, dsp_freq=f_dsp, rf_freq_policy=uhd.tune_request.POLICY_AUTO, dsp_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>g_ref</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>device_address</value></param>
<param><key>dev_args</key><value>device_arguments</value></param>
<param><key>sd_spec0</key><value>A:A A:B</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_1</value></param>
<param><key>address</key><value>"tcp://*:{}".format(port_base + 0)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_1_0</value></param>
<param><key>address</key><value>"tcp://*:{}".format(port_base + 2)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_1_0_0</value></param>
<param><key>address</key><value>"tcp://*:{}".format(port_base + 3)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**3</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_1_1</value></param>
<param><key>address</key><value>"tcp://*:{}".format(port_base + 1)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>zeromq_pub_sink</key>
<param><key>id</key><value>zeromq_pub_sink_0_1_2</value></param>
<param><key>address</key><value>"tcp://*:{}".format(port_base + 9)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0</value></param>
<param><key>address</key><value>tcp://localhost:6882</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**2</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_0</value></param>
<param><key>address</key><value>tcp://localhost:6883</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**3</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_1</value></param>
<param><key>address</key><value>tcp://localhost:6881</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**1</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_2</value></param>
<param><key>address</key><value>"tcp://localhost:{}".format(port_base + 0)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<block>
<key>zeromq_sub_source</key>
<param><key>id</key><value>zeromq_sub_source_0_2_0</value></param>
<param><key>address</key><value>"tcp://localhost:{}".format(port_base + 9)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>pass_tags</key><value>pass_tags</value></param>
<param><key>timeout</key><value>100</value></param>
<param><key>vlen</key><value>decim**0</value></param>
</block>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_ctrlport_probe2_c_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0_1</source_block_id><sink_block_id>blocks_file_meta_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>zeromq_pub_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>zeromq_pub_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>zeromq_pub_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>zeromq_pub_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1_0</source_block_id><sink_block_id>zeromq_pub_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>Ampm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_ctrlport_probe2_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>Ampm_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_ctrlport_probe2_c_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_1</source_block_id><sink_block_id>blocks_head_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_2</source_block_id><sink_block_id>blocks_file_meta_sink_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_sub_source_0_2_0</source_block_id><sink_block_id>blocks_file_meta_sink_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_source</value></param>
<param><key>value</key><value>4.789e6</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>step</key><value>.1e6</value></param>
<param><key>stop</key><value>100e6</value></param>
</block>
<block>
<key>Ampm</key>
<param><key>id</key><value>Ampm_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>decim_df</key><value>decim_df</value></param>
<param><key>decim_f</key><value>decim_f</value></param>
<param><key>f_sample</key><value>f_sample</value></param>
<param><key>f_source</key><value>f_source</value></param>
<param><key>host</key><value>host</value></param>
<param><key>n_samples</key><value>n_samples</value></param>
<param><key>name</key><value>name</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_df</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_df_0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_f_0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.45</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample_0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_source_0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>host</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>localhost</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n_samples</value></param>
<param><key>type</key><value>long</value></param>
<param><key>value</key><value>1&lt;&lt;24</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>test6</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>f_sample/decim</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>1</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>f_sample/decim</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>ylabel</key><value>noise</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>f_sample</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>ylabel</key><value>in</value></param>
</block>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Ampm_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

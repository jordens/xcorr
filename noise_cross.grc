<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NoiseCross</value></param>
<param><key>title</key><value>Noise Cross Correlation Detector</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cross_alpha</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0_1_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0_1_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0_1_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>decim**3</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0_1_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_stages</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>imag</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>real</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>a</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>b</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>label</key><value>freqs</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>owidth</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_1</value></param>
<param><key>n</key><value>1.</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_f</value></param>
<param><key>value</key><value>.45</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_df</value></param>
<param><key>value</key><value>.1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>decim</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>decim**2</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>decim**3</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0_3</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0_2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>decim_f/decim</value></param>
<param><key>width</key><value>decim_df/decim</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>1.</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>blocks_message_source</key>
<param><key>id</key><value>blocks_message_source_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>LogStitch</key>
<param><key>id</key><value>LogStitch_0</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>width</key><value>fft_width</value></param>
<param><key>stages</key><value>decim_stages</value></param>
<param><key>owidth</key><value>owidth</value></param>
<param><key>cutoff</key><value>decim_f-decim_df/2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import log10, pi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>value</key><value>400e3</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10.</value></param>
<param><key>k</key><value>1.</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>n</key><value>10.</value></param>
<param><key>k</key><value>1.</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_width</value></param>
<param><key>value</key><value>128</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_window</value></param>
<param><key>value</key><value>"window.blackmanharris"</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0_1_0</value></param>
<param><key>skip</key><value>1</value></param>
<param><key>average_alpha</key><value>cross_alpha</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0_1</value></param>
<param><key>skip</key><value>1</value></param>
<param><key>average_alpha</key><value>cross_alpha</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0_1_1</value></param>
<param><key>skip</key><value>1</value></param>
<param><key>average_alpha</key><value>cross_alpha</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0_1_2</value></param>
<param><key>skip</key><value>1</value></param>
<param><key>average_alpha</key><value>cross_alpha</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0_1_2_0</value></param>
<param><key>skip</key><value>1</value></param>
<param><key>average_alpha</key><value>cross_alpha</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0_1_2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>skip</key><value>1</value></param>
<param><key>average_alpha</key><value>cross_alpha</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>low_pass_filter_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>Xfft_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Xfft_0_1_0</source_block_id><sink_block_id>blocks_message_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0_1_0</source_block_id><sink_block_id>blocks_message_source_0_1_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0_1</source_block_id><sink_block_id>blocks_message_source_0_1</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>Xfft_0_1</source_block_id><sink_block_id>blocks_message_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0</source_block_id><sink_block_id>Xfft_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0_1_1</source_block_id><sink_block_id>blocks_message_source_0_1_1</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>Xfft_0_1_1</source_block_id><sink_block_id>blocks_message_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_3</source_block_id><sink_block_id>low_pass_filter_0_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0</source_block_id><sink_block_id>low_pass_filter_0_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_3</source_block_id><sink_block_id>Xfft_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_1</source_block_id><sink_block_id>low_pass_filter_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_1</source_block_id><sink_block_id>Xfft_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_2</source_block_id><sink_block_id>Xfft_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_2</source_block_id><sink_block_id>low_pass_filter_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_source_0_1_2</source_block_id><sink_block_id>blocks_repeat_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0_1_2</source_block_id><sink_block_id>blocks_message_source_0_1_2</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>Xfft_0_1_2</source_block_id><sink_block_id>blocks_message_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0_1_2_0_0</source_block_id><sink_block_id>blocks_message_source_0_1_2_0_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>Xfft_0_1_2_0_0</source_block_id><sink_block_id>blocks_message_sink_0_1_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_source_0_1_2_0_0</source_block_id><sink_block_id>blocks_repeat_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0_0_0_0_0</source_block_id><sink_block_id>Xfft_0_1_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0_0_0_0_0</source_block_id><sink_block_id>LogStitch_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0_0_0_0</source_block_id><sink_block_id>LogStitch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>LogStitch_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>LogStitch_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_1</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Xfft_0_1_2_0</source_block_id><sink_block_id>blocks_repeat_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_source_0_1_1</source_block_id><sink_block_id>blocks_repeat_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0_0_0_0_0_0</source_block_id><sink_block_id>LogStitch_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_message_source_0_1</source_block_id><sink_block_id>LogStitch_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_message_source_0_1_0</source_block_id><sink_block_id>LogStitch_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
</flow_graph>

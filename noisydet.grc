<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>NoisyDet</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>am</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pm</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_lowpass</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi, exp, cos, sin</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>rf</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0_0_0_0_0_0</value></param>
<param><key>pm</key><value>pm</value></param>
<param><key>am</key><value>am</value></param>
<param><key>seed</key><value>631+seed</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>am_alpha</key><value>.1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>lo</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0_0_0_0_0</value></param>
<param><key>pm</key><value>pm</value></param>
<param><key>am</key><value>am</value></param>
<param><key>seed</key><value>234+seed</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>am_alpha</key><value>.1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>if</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1.</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>f_lowpass</value></param>
<param><key>width</key><value>0.2*f_lowpass</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ref</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>cos(pi*ref) + 1j*sin(pi*ref)</value></param>
</block>
<connection><source_block_id>APNoise_0_0_0_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>APNoise_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0</source_block_id><sink_block_id>APNoise_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

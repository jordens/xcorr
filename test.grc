<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>f + df_ref</value></param>
<param><key>amp</key><value>1.</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>num_tabs</key><value>4</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Noise</value></param>
<param><key>label2</key><value>Correlated</value></param>
<param><key>label3</key><value>Test</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>df_ref</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>start</key><value>-10e-6</value></param>
<param><key>stop</key><value>10e-6</value></param>
<param><key>step</key><value>.01e-6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_source</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>f</value></param>
<param><key>amp</key><value>1.</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>NoiseConvert</key>
<param><key>id</key><value>NoiseConvert_0_0</value></param>
<param><key>decim</key><value>decim_convert</value></param>
<param><key>df_ref</key><value>df_ref</value></param>
<param><key>f</key><value>f</value></param>
<param><key>decim_f</key><value>.5</value></param>
<param><key>decim_df</key><value>.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_center</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>stop</key><value>32e6</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0.</value></param>
<param><key>start</key><value>-30.</value></param>
<param><key>stop</key><value>30.</value></param>
<param><key>step</key><value>1.</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cross_alpha</value></param>
<param><key>value</key><value>2.</value></param>
<param><key>start</key><value>0.</value></param>
<param><key>stop</key><value>4.</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>am_sig</value></param>
<param><key>value</key><value>-120</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>-60</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pm_sig</value></param>
<param><key>value</key><value>-120</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>-60</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>am_corr</value></param>
<param><key>value</key><value>-120</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>-60</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>pm_corr</value></param>
<param><key>value</key><value>-120</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>-60</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>gui_hint</key><value>tab@3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_cross</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_stages</value></param>
<param><key>value</key><value>5</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_window</value></param>
<param><key>value</key><value>lambda n: []</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decim_convert</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_width</value></param>
<param><key>value</key><value>128</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>owidth</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>name</key><value>Real Sab</value></param>
<param><key>vlen</key><value>owidth</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>x_axis_label</key><value></value></param>
<param><key>y_axis_label</key><value></value></param>
<param><key>x_units</key><value></value></param>
<param><key>y_units</key><value></value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>Re PM</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>alpha1</key><value>1.</value></param>
<param><key>label2</key><value>Re AM</value></param>
<param><key>width2</key><value>2</value></param>
<param><key>alpha2</key><value>1.</value></param>
<param><key>label3</key><value>Im PM</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>alpha3</key><value>.7</value></param>
<param><key>label4</key><value>Im AM</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>alpha4</key><value>.7</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1_0</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1_0_0</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>owidth</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>owidth</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>owidth</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>owidth</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1_1</value></param>
<param><key>vlen</key><value>owidth</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>owidth</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-180</value></param>
<param><key>ymax</key><value>0.</value></param>
<param><key>xmin</key><value>-6.5</value></param>
<param><key>xmax</key><value>-.3</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label1</key><value>re pm</value></param>
<param><key>width1</key><value>2</value></param>
<param><key>style1</key><value>1</value></param>
<param><key>marker1</key><value>-1</value></param>
<param><key>label2</key><value>im pm</value></param>
<param><key>color2</key><value>"blue"</value></param>
<param><key>style2</key><value>1</value></param>
<param><key>marker2</key><value>-1</value></param>
<param><key>label3</key><value>re am</value></param>
<param><key>width3</key><value>2</value></param>
<param><key>color3</key><value>"red"</value></param>
<param><key>style3</key><value>1</value></param>
<param><key>marker3</key><value>-1</value></param>
<param><key>label4</key><value>im am</value></param>
<param><key>color4</key><value>"red"</value></param>
<param><key>style4</key><value>1</value></param>
<param><key>marker4</key><value>-1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>f</value></param>
<param><key>bw</key><value>f_sample/decim_convert</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label2</key><value></value></param>
<param><key>label3</key><value></value></param>
<param><key>label4</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>f_sample/decim_convert</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label1</key><value>pm a</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value>pm b</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label3</key><value>am a</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label4</key><value>am b</value></param>
<param><key>color4</key><value>"black"</value></param>
</block>
<block>
<key>NoiseCross</key>
<param><key>id</key><value>NoiseCross_1</value></param>
<param><key>cross_alpha</key><value>10**-cross_alpha</value></param>
<param><key>decim_stages</key><value>decim_stages</value></param>
<param><key>owidth</key><value>owidth</value></param>
<param><key>decim_f</key><value>.5</value></param>
<param><key>decim_df</key><value>.1</value></param>
<param><key>gain</key><value>decim_cross**.5</value></param>
<param><key>decim</key><value>decim_cross</value></param>
<param><key>f_sample</key><value>f_sample/decim_convert</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>NoiseCross</key>
<param><key>id</key><value>NoiseCross_1_0</value></param>
<param><key>cross_alpha</key><value>10**-cross_alpha</value></param>
<param><key>decim_stages</key><value>decim_stages</value></param>
<param><key>owidth</key><value>owidth</value></param>
<param><key>decim_f</key><value>.5</value></param>
<param><key>decim_df</key><value>.1</value></param>
<param><key>gain</key><value>decim_cross**.5</value></param>
<param><key>decim</key><value>decim_cross</value></param>
<param><key>f_sample</key><value>f_sample/decim_convert</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>fft_window</key><value>fft_window</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Input Signals</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>1.</value></param>
<param><key>ymin</key><value>-160</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>update_time</key><value>0.2</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>sig a</value></param>
<param><key>label2</key><value>sig b</value></param>
<param><key>label3</key><value>ref a</value></param>
<param><key>label4</key><value>ref b</value></param>
</block>
<block>
<key>usrp_4ch_source</key>
<param><key>id</key><value>usrp_4ch_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>f_sample</key><value>f_sample</value></param>
<param><key>f_sig</key><value>0.</value></param>
<param><key>f_ref</key><value>0.</value></param>
</block>
<block>
<key>test_4ch_source</key>
<param><key>id</key><value>test_4ch_source_0</value></param>
<param><key>pm_corr</key><value>10**(pm_corr/20)</value></param>
<param><key>am_sig</key><value>10**(am_sig/20)</value></param>
<param><key>pm_sig</key><value>10**(pm_sig/20)</value></param>
<param><key>f_sample</key><value>f_sample</value></param>
<param><key>am_corr</key><value>10**(am_corr/20)</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>f_source</key><value>f_source</value></param>
</block>
<block>
<key>NoiseConvert</key>
<param><key>id</key><value>NoiseConvert_0</value></param>
<param><key>decim</key><value>decim_convert</value></param>
<param><key>df_ref</key><value>df_ref</value></param>
<param><key>f</key><value>f</value></param>
<param><key>decim_f</key><value>.5</value></param>
<param><key>decim_df</key><value>.1</value></param>
</block>
<connection><source_block_id>NoiseConvert_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseConvert_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>NoiseConvert_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>NoiseConvert_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseConvert_0</source_block_id><sink_block_id>NoiseCross_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseConvert_0_0</source_block_id><sink_block_id>NoiseCross_1_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>NoiseConvert_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>NoiseConvert_0_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>NoiseConvert_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>NoiseConvert_0</source_block_id><sink_block_id>NoiseCross_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseConvert_0_0</source_block_id><sink_block_id>NoiseCross_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>NoiseConvert_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseConvert_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>NoiseConvert_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>NoiseConvert_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>NoiseConvert_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>test_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>usrp_4ch_source_0</source_block_id><sink_block_id>NoiseConvert_0</sink_block_id><source_key>3</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseCross_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>NoiseCross_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseCross_1</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseCross_1</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseCross_1</source_block_id><sink_block_id>blocks_float_to_complex_1_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseCross_1</source_block_id><sink_block_id>blocks_float_to_complex_1_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseCross_1_0</source_block_id><sink_block_id>blocks_float_to_complex_1_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseCross_1_0</source_block_id><sink_block_id>blocks_float_to_complex_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseCross_1_0</source_block_id><sink_block_id>blocks_float_to_complex_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseCross_1_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>NoiseCross_1_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1_1</source_block_id><sink_block_id>blocks_vector_to_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoiseCross_1_0</source_block_id><sink_block_id>blocks_float_to_complex_1_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>

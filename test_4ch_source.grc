<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_4ch_source</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pm_corr</value></param>
<param><key>value</key><value>2e-6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>am_sig</value></param>
<param><key>value</key><value>1e-6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pm_sig</value></param>
<param><key>value</key><value>1e-6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>value</key><value>4e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>sig_a</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>label</key><value>sig_b</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_1</value></param>
<param><key>label</key><value>ref_a</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>label</key><value>ref_b</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>am_corr</value></param>
<param><key>value</key><value>2e-6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0</value></param>
<param><key>pm</key><value>pm_sig</value></param>
<param><key>am</key><value>am_sig</value></param>
<param><key>am_alpha</key><value>.1</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>seed</key><value>0+seed*5</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0_0</value></param>
<param><key>pm</key><value>pm_corr</value></param>
<param><key>am</key><value>am_corr</value></param>
<param><key>am_alpha</key><value>.1</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>seed</key><value>1+seed*5</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0_0_0</value></param>
<param><key>pm</key><value>pm_corr</value></param>
<param><key>am</key><value>am_corr</value></param>
<param><key>am_alpha</key><value>.1</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>seed</key><value>2+seed*5</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0_0_1</value></param>
<param><key>pm</key><value>pm_corr</value></param>
<param><key>am</key><value>am_corr</value></param>
<param><key>am_alpha</key><value>.1</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>seed</key><value>3+seed*5</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0_0_0_0</value></param>
<param><key>pm</key><value>pm_corr</value></param>
<param><key>am</key><value>am_corr</value></param>
<param><key>am_alpha</key><value>.1</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>seed</key><value>4+seed*5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>seed</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>f_source</value></param>
<param><key>amp</key><value>1.</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_source</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>f_sample</value></param>
</block>
<connection><source_block_id>APNoise_0</source_block_id><sink_block_id>APNoise_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0</source_block_id><sink_block_id>APNoise_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>APNoise_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>APNoise_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0_0_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0_0_1</source_block_id><sink_block_id>pad_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0_0_0_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>APNoise_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

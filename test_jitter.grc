<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>f_source</value></param>
<param><key>value</key><value>0</value></param>
<param><key>num_opts</key><value>4</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1.234567e3</value></param>
<param><key>option2</key><value>1.234567e6</value></param>
<param><key>option3</key><value>31.34567e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>f_sample</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>4096</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>f_source</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>f_source</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>fpga=usrp_b100_fpga_2rx.bin</value></param>
<param><key>sd_spec0</key><value>A:A A:B</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>

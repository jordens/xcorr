<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8rc1'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>unwrap_2</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_int</key>
<param><key>id</key><value>blocks_float_to_int_0</value></param>
<param><key>scale</key><value>.5/discont</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>.5/discont</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>discont</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>pi</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1., -1.]</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>iir_filter_xxx</key>
<param><key>id</key><value>iir_filter_xxx_0</value></param>
<param><key>fftaps</key><value>[-1.]</value></param>
<param><key>fbtaps</key><value>[1., 1.]</value></param>
<param><key>type</key><value>ffd</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_int_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>iir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_float_to_int_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>iir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

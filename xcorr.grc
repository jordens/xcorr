<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Xcorr</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>int(1/lowpass_f)</value></param>
<param><key>gain</key><value>1.</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>cutoff_freq</key><value>lowpass_f</value></param>
<param><key>width</key><value>0.2*lowpass_f</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>w</key><value>f_loop</value></param>
<param><key>max_freq</key><value>0.1*f_sample</value></param>
<param><key>min_freq</key><value>0.9*f_sample</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_width</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Input</value></param>
<param><key>fftsize</key><value>fft_width</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0.</value></param>
<param><key>bw</key><value>f_sample</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>3,0,3,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>in_a</value></param>
<param><key>label2</key><value>in_a</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>f_sample</value></param>
<param><key>center_freq0</key><value>f_center</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq1</key><value>f_center</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>ant1</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_center</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>-30</value></param>
<param><key>stop</key><value>30</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>

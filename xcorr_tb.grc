<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.5'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>xcorr_tb</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>Xfft</key>
<param><key>id</key><value>Xfft_0</value></param>
<param><key>fft_width</key><value>fft_width</value></param>
<param><key>average_alpha</key><value>10**-average_alpha_10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>n</key><value>10</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>fft_width</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sample</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>cor_a</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>cor_b</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>cor_b</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>lo</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>1.</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>.25</value></param>
<param><key>amp</key><value>1.</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>APNoise</key>
<param><key>id</key><value>APNoise_0</value></param>
<param><key>pm</key><value>dut_pm</value></param>
<param><key>am</key><value>dut_am</value></param>
<param><key>seed</key><value>57294</value></param>
<param><key>pm_alpha</key><value>.1</value></param>
<param><key>am_alpha</key><value>.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_lowpass</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,4,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dut_am</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cor_am</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>cor_pm</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>average_alpha_10</value></param>
<param><key>value</key><value>2</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>5</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,5,1,1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>f_sample</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_width</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Input</value></param>
<param><key>fftsize</key><value>fft_width</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0.</value></param>
<param><key>bw</key><value>f_sample</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>4,0,3,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>in_a</value></param>
<param><key>label2</key><value>in_a</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Detect</value></param>
<param><key>fftsize</key><value>fft_width</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>f_sample</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>4,2,3,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>in_a</value></param>
<param><key>label2</key><value>in_a</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>name</key><value>Correlator power spectrum</value></param>
<param><key>vlen</key><value>fft_width</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>x_axis_label</key><value></value></param>
<param><key>y_axis_label</key><value></value></param>
<param><key>x_units</key><value></value></param>
<param><key>y_units</key><value></value></param>
<param><key>ymin</key><value>-180</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>4,4,3,2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>label1</key><value>real</value></param>
<param><key>label2</key><value>imag</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>lo</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dut_pm</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1.</value></param>
<param><key>step</key><value>.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ref_b</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>0</value></param>
<param><key>true</key><value>.5</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ref_a</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>0</value></param>
<param><key>true</key><value>.5</value></param>
<param><key>false</key><value>0</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_b</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>.5</value></param>
<param><key>step</key><value>.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_a</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>.5</value></param>
<param><key>step</key><value>.001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>cor_a</value></param>
</block>
<block>
<key>NoisyDet</key>
<param><key>id</key><value>NoisyDet_0_0_0</value></param>
<param><key>am</key><value>cor_am</value></param>
<param><key>pm</key><value>cor_pm</value></param>
<param><key>seed</key><value>428592</value></param>
<param><key>f_lowpass</key><value>f_lowpass</value></param>
<param><key>ref</key><value>phase_a+ref_a</value></param>
</block>
<block>
<key>NoisyDet</key>
<param><key>id</key><value>NoisyDet_0_0</value></param>
<param><key>am</key><value>cor_am</value></param>
<param><key>pm</key><value>cor_pm</value></param>
<param><key>seed</key><value>4022</value></param>
<param><key>f_lowpass</key><value>f_lowpass</value></param>
<param><key>ref</key><value>phase_b+ref_b</value></param>
</block>
<connection><source_block_id>APNoise_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0</source_block_id><sink_block_id>NoisyDet_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>APNoise_0</source_block_id><sink_block_id>NoisyDet_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoisyDet_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoisyDet_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>APNoise_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>NoisyDet_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0_0</source_block_id><sink_block_id>Xfft_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>Xfft_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Xfft_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Xfft_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_complex_to_real_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoisyDet_0_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>NoisyDet_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>NoisyDet_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
